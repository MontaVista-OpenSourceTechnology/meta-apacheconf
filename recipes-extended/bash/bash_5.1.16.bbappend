
FILESEXTRAPATHS:prepend := "${THISDIR}/bash:"

SRC_URI += "file://0001-Re-add-the-shellshock-vulnerability.patch"
